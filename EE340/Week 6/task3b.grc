options:
  parameters:
    author: Prasann
    generate_options: qt_gui
    id: lab5_task3b
    output_language: python
    title: Lab 5 Task 3b
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: fll_ntaps
  id: variable
  parameters:
    value: '55'
  states: {}
- name: freq_bw
  id: variable
  parameters:
    value: 2*pi/100
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: 11*nfilts*sps
  states: {}
- name: rx_taps
  id: variable
  parameters:
    value: filter.firdes.root_raised_cosine(nfilts, nfilts*sps, 1.0, excess_bw, ntaps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: timing_bw
  id: variable
  parameters:
    value: 2*pi/100
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: '500000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: '500000'
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\HOME\Desktop\SEM 5\EE340 - Comms. Lab\Lab 6\input2.bin
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*sps
    type: complex
  states: {}
- name: blocks_throttle_0_0_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*sps
    type: complex
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: sps
    mu: '0.01'
    num_taps: '16'
    sps: '1'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: freq_bw
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: fll_ntaps
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: freq_bw
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '16'
    loop_bw: timing_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rx_taps
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi as pi
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: import_2
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '1'
    gain: '1'
    samp_rate: '500000'
    type: fir_filter_fff
    width: '10000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '1'
    gain: '1'
    samp_rate: '500000'
    type: fir_filter_fff
    width: '10000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate*sps
    fc: '0'
    fftsize: '1024'
    gui_hint: tab_widget@0
    name: Pre polyphase
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab_widget@1
    name: Output of Pulse Shape Filter
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab_widget@2
    name: Output of Pulse Shape Filter
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: tab_widget
  id: qtgui_tab_widget
  parameters:
    label0: Complex Baseband
    label1: Before Costas Sync
    label2: After Costas
    num_tabs: '3'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_file_source_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_1, '0']
- [blocks_throttle_0_0_0, '0', qtgui_sink_x_0_0_0, '0']
- [blocks_throttle_0_0_0_0, '0', qtgui_sink_x_0_0_0_0, '0']
- [blocks_throttle_0_0_0_1, '0', qtgui_sink_x_0_0, '0']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_throttle_0_0_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_throttle_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0, '0']
- [low_pass_filter_0, '0', blocks_float_to_complex_0, '0']
- [low_pass_filter_1, '0', blocks_float_to_complex_0, '1']
- [rational_resampler_xxx_0, '0', blocks_throttle_0_0_0_1, '0']
- [rational_resampler_xxx_0, '0', digital_fll_band_edge_cc_0, '0']

metadata:
  file_format: 1
