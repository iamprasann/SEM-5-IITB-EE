options:
  parameters:
    author: Prsn
    generate_options: qt_gui
    id: lab3_task1b
    output_language: python
    title: Lab 3 Task 1b
  states: {}

blocks:
- name: carrier
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_car
  id: variable
  parameters:
    value: '3582000'
  states: {}
- name: samp_rate_op
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_phase_modulator_fc_0
  id: analog_phase_modulator_fc
  parameters:
    sensitivity: '471000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '200000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_car
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/iamprasann/Desktop/EE340-Comms. Lab/Week 3/music.wav
    repeat: 'True'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '1'
    fftaps: '[1, -0.95]'
    type: ffd
  states: {}
- name: iir_filter_xxx_1
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1, 1]'
    fftaps: '0.0000226757'
    type: ffd
  states: {}
- name: iir_filter_xxx_2
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1, -0.95]'
    fftaps: '1'
    type: ffd
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '14000'
    decim: '1'
    gain: '4'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '320'
    fbw: '0.4'
    interp: '441'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '441'
    fbw: '0.4'
    interp: '35280'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '80'
    fbw: '0.4'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    decim: '441'
    fbw: '0.4'
    interp: '320'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_phase_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_1, '0']
- [blocks_complex_to_float_0, '1', blocks_delay_0, '0']
- [blocks_complex_to_float_0, '1', blocks_sub_xx_0, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_xx_1, '0', rational_resampler_xxx_2, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_1, '1']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [dc_blocker_xx_0, '0', low_pass_filter_0, '0']
- [iir_filter_xxx_0, '0', iir_filter_xxx_1, '0']
- [iir_filter_xxx_1, '0', analog_phase_modulator_fc_0, '0']
- [iir_filter_xxx_2, '0', rational_resampler_xxx_3, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_0, '0', iir_filter_xxx_0, '0']
- [rational_resampler_xxx_1, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_2, '0', iir_filter_xxx_2, '0']
- [rational_resampler_xxx_3, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
