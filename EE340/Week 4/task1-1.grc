options:
  parameters:
    author: prsn
    generate_options: qt_gui
    id: task1_1
    output_language: python
    title: Task 1.1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_0
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '-1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_0
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_0
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/iamprasann/Desktop/EE340-Comms. Lab/Week 4/music.wav
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: /home/iamprasann/Desktop/EE340-Comms. Lab/Week 4/vocal.wav
    repeat: 'False'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Final"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    fbw: '0.4'
    interp: samp_rate_0
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    fbw: '0.4'
    interp: samp_rate_0
    taps: ''
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_1, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '1']
- [rational_resampler_xxx_1, '0', blocks_multiply_xx_1, '0']

metadata:
  file_format: 1
